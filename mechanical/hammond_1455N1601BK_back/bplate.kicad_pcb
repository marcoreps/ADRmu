File: mechanical/hammond_1455N1601BK_back/bplate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 103 x 53 mm, 11 parts

Commit message: Rev. 1.0
Parts:
- moved G*** 3.17 mm to (138.4, 97.5)
